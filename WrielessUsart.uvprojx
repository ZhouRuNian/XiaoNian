# Keil uVision project WrielessUsart.uvprojx, settings and files
target WrilessUsart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: WrielessUsart +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=2
  c include: .\DeviceDriver;.\DeviceDriver\inc;.\DeviceDriver\src;.\User;.\UserDriver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./DeviceDriver/: interrupts_hc32l13x.c system_hc32l13x.c startup_hc32l13x.s
  group DeviceDriver
    ./DeviceDriver/src/: ddl.c dmac.c flash.c gpio.c reset.c rtc.c uart.c sysctrl.c lptim.c lpm.c bt.c
  group User
    ./User/: main.c
    ./UserDriver/: WHOLE_LIBRARY.h
  group UserDriver
    ./UserDriver/: DELAY.c CRC-8.c EEPROM.c FLASH_IAP.c LED.c UART_MAIN.c UART_READER.c IWDG.c VOLTAGE.c TIMER.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:NN Lib 3.0.0
